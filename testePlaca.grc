options:
  parameters:
    generate_options: qt_gui
    id: testePlaca
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: center_freq
  id: variable_qtgui_range
  parameters:
    start: 85e6
    step: 50e3
    stop: 110e6
    value: 100e6
  states: {}
- name: channel_w
  id: variable
  parameters:
    value: 200e3
  states: {}
- name: ganho
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: center_freq +  channel_w
    low_cutoff_freq: center_freq -  channel_w
    samp_rate: (center_freq + channel_w) * 3
    type: fir_filter_ccf
    width: channel_w
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    freq0: center_freq
    gain0: '0'
    gain_mode0: 'True'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    grid: 'True'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: channel_w
    fc: center_freq
    fftsize: '1024'
    grid: 'True'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
  states: {state: disabled}

connections:
- [band_pass_filter_0, '0', qtgui_freq_sink_x_0_0, '0']
- [osmosdr_source_0, '0', band_pass_filter_0, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
